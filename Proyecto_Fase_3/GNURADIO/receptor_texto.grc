options:
  parameters:
    description: 'Base de continuidad: fuente, agrupacion, mapeo de constelacion, conformacion RRC de transmision y canal AWGN. No incluye receptor.'
    generate_options: qt_gui
    id: receptor_texto_dbpsk
    output_language: python
    title: Rx DBPSK HackRF - mensaje de texto
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: len(tabla_de_verdad_constelacion)
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: beta
  id: variable_qtgui_range
  parameters:
    label: Roll-off beta
    start: '0.10'
    step: '0.05'
    stop: '1.0'
    value: '0.35'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: fc
  id: variable
  parameters:
    value: 930e6
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    label: Amplitud de ruido AWGN
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.10'
  states: {}
- name: rrc_tx_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: beta
    gain: Sps
    ntaps: span*Sps
    samp_rate: samp_rate
    sym_rate: Rs
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: span
  id: variable
  parameters:
    value: '11'
  states: {}
- name: tabla_de_verdad_constelacion
  id: variable
  parameters:
    comment: Cambie esta tabla para OOK ASK BPSK QPSK 8PSK o 16QAM
    value: (-1+0j, 1+0j)
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1+0j, 1+0j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1, 1] '
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.0628'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    comment: |-
      Ancho de lazo reducido (0.0628 -> 0.02):
      con 0.0628 el jitter de frecuencia rompia las tramas
    filter_size: 2*Sps+1
    rolloff: beta
    samps_per_sym: Sps
    type: cc
    w: '0.02'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: Sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '20'
    corr0: ppm
    freq0: fc
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '16'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: '"Salida del canal + AWGN"'
    legend: 'False'
    name: '"Plano I-Q sobremuestreado a la salida del canal"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    label1: Diagrama de ojo
    label2: 'Diagrama de ojo con ruido '
    samp_per_symbol: Sps
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    grid: 'True'
    label1: Tx despues de RRC
    name: '"PSD: Tx conformada vs salida del canal"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: I
    label2: Q
    name: '"Envolvente compleja a la salida del canal"'
    size: '1024'
    srate: Rs
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*Sps
    samp_rate: samp_rate
    sym_rate: Rs
    type: fir_filter_ccf
  states: {}
- name: access_code
  id: variable
  parameters:
    comment: Debe ser IGUAL al del transmisor
    value: digital.packet_utils.default_access_code
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    type: byte
    access_code: access_code
    threshold: '2'
    tagname: '"packet_len"'
    comment: |-
      Busca el access code, lee la longitud
      y entrega solo los bits del payload
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    comment: Bits -> bytes
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    type: byte
    tag: packet_len
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'True'
    comment: Descarta tramas con errores
  states: {}
- name: epy_pdu_a_texto
  id: epy_block
  parameters:
    _source_code: |
      """
      Muestra el texto recibido.
       - Entrada 'pdus'  : tramas con CRC correcto -> salida 'texto'
       - Entrada 'crudo' : todas las tramas detectadas (sin verificar CRC, se quitan
                           los 4 bytes del CRC) -> salida 'texto_crudo'
      Imprime en la consola cuantas tramas se detectaron y cuantas pasaron el CRC.
      """
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name='PDU a texto', in_sig=None, out_sig=None)
              for p in ('pdus', 'crudo'):
                  self.message_port_register_in(pmt.intern(p))
              self.message_port_register_out(pmt.intern('texto'))
              self.message_port_register_out(pmt.intern('texto_crudo'))
              self.set_msg_handler(pmt.intern('pdus'), self.handle_ok)
              self.set_msg_handler(pmt.intern('crudo'), self.handle_raw)
              self.n = 0
              self.n_det = 0

          @staticmethod
          def _texto(msg, quitar=0):
              datos = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              if quitar:
                  datos = datos[:-quitar]
              return datos.decode('utf-8', errors='replace')

          def handle_raw(self, msg):
              self.n_det += 1
              self.message_port_pub(pmt.intern('texto_crudo'), pmt.intern(self._texto(msg, 4)))
              if self.n_det % 50 == 0:
                  print('[RX] tramas detectadas: %d | con CRC correcto: %d' % (self.n_det, self.n), flush=True)

          def handle_ok(self, msg):
              self.n += 1
              texto = self._texto(msg)
              print('[RX #%d] %s' % (self.n, texto), flush=True)
              self.message_port_pub(pmt.intern('texto'), pmt.intern(texto))
    comment: |-
      Imprime el texto en consola
      y lo envia a los cuadros QT
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    type: string
    label: Mensaje recibido (CRC correcto)
    is_pair: 'False'
    is_static: 'False'
    gui_hint: 0,0,1,2
  states: {}
- name: dc_blocker
  id: dc_blocker_xx
  parameters:
    type: cc
    length: '1024'
    long_form: 'True'
    comment: |-
      Quita el pico DC del HackRF (LO leakage del Rx).
      Sin esto el AGC y la sincronizacion se pierden.
  states: {}
- name: qtgui_edit_box_msg_1
  id: qtgui_edit_box_msg
  parameters:
    type: string
    label: Trama detectada sin verificar CRC (puede tener errores)
    is_pair: 'False'
    is_static: 'False'
    gui_hint: 1,0,1,2
    comment: |-
      Diagnostico: si aqui aparece texto con errores
      pero arriba no, el enlace tiene bit errors (ajuste ganancias)
  states: {}
- name: ppm
  id: variable_qtgui_range
  parameters:
    comment: Correccion del oscilador del HackRF Rx
    label: Correccion de frecuencia (ppm)
    start: '-40'
    step: '0.5'
    stop: '40'
    value: '0'
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', qtgui_time_sink_x_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_chunks_to_symbols_xx_1, '0']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_eye_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, digital_crc32_async_bb_0, in]
- [digital_crc32_async_bb_0, out, epy_pdu_a_texto, pdus]
- [epy_pdu_a_texto, texto, qtgui_edit_box_msg_0, val]
- [osmosdr_source_0, '0', dc_blocker, '0']
- [dc_blocker, '0', analog_agc_xx_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_pdu_a_texto, crudo]
- [epy_pdu_a_texto, texto_crudo, qtgui_edit_box_msg_1, val]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
