options:
  parameters:
    description: 'Transmite un mensaje de texto en tramas: preambulo + access code + longitud + texto + CRC32, modulado en DBPSK con RRC.'
    generate_options: qt_gui
    id: transmisor_texto_dbpsk
    output_language: python
    title: Tx DBPSK HackRF - mensaje de texto
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: len(tabla_de_verdad_constelacion)
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: access_code
  id: variable
  parameters:
    comment: Debe ser IGUAL en el receptor
    value: digital.packet_utils.default_access_code
  states: {}
- name: beta
  id: variable_qtgui_range
  parameters:
    label: Roll-off beta
    start: '0.10'
    step: '0.05'
    stop: '1.0'
    value: '0.35'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: fc
  id: variable
  parameters:
    value: 930e6
  states: {}
- name: mensaje
  id: variable_qtgui_entry
  parameters:
    label: Mensaje a transmitir
    type: string
    value: Comunicaciones 2!
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    label: Amplitud de ruido AWGN
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.10'
  states: {}
- name: payload
  id: variable
  parameters:
    comment: Texto en UTF-8 + CRC32 (4 bytes, little endian)
    value: list(bytes(mensaje, 'utf-8')) + list(zlib.crc32(bytes(mensaje, 'utf-8')).to_bytes(4, 'little'))
  states: {}
- name: rrc_tx_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: beta
    gain: Sps
    ntaps: 11*Sps
    samp_rate: samp_rate
    sym_rate: Rs
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: span
  id: variable
  parameters:
    value: '11'
  states: {}
- name: tabla_de_verdad_constelacion
  id: variable
  parameters:
    value: (-1+0j, 1+0j)
  states: {}
- name: trama
  id: variable
  parameters:
    comment: Preambulo 0x55 + access code (8 bytes) + longitud 16 bits x2 + payload
    value: '[0x55]*16 + [int(access_code[i:i+8], 2) for i in range(0, len(access_code), 8)] + [len(payload) >> 8, len(payload) & 0xFF]*2 + payload'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1+0j, 1+0j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: bits_to_symbols
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: bps
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    maxoutbuf: '256'
    repeat: 'True'
    type: byte
    vector: trama
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: tabla_de_verdad_constelacion
  states: {}
- name: digital_diff_encoder_bb_0_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math, zlib
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '''hackrf=0'''
    bb_gain0: '34'
    freq0: fc
    gain0: '14'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rrc_tx
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: rrc_tx_taps
    type: ccf
  states: {}

connections:
- [analog_random_source_x_0, '0', bits_to_symbols, '0']
- [bits_to_symbols, '0', digital_diff_encoder_bb_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_vector_source_x_0, '0', bits_to_symbols, '0']
- [digital_chunks_to_symbols_xx_0, '0', rrc_tx, '0']
- [digital_diff_encoder_bb_0_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [rrc_tx, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
